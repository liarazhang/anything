# Keil uVision project 最终.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 最终 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    C:/Users/zxy19/Desktop/: 小车车最终版.c
