# Keil uVision project SUIBIAN.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: SUIBIAN +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    F:/HC6800-EM3 V3.0   (9.22)/5--实验程序/基础实验例程/实验1：点亮第一个LED/程序/: main.c
